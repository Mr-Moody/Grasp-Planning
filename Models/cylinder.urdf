Commit message: Sampling for all grippers and objects

File: Models/cylinder.urdf (robot description, URDF)
Before this commit: robot cylinder_robot, 1 links, 0 joints
Links:
- link cylinder_link: geometry collision cylinder length=0.12 radius=0.02; visual cylinder length=0.12 radius=0.02
